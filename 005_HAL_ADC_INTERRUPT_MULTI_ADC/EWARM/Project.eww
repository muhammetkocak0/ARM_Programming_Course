<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\005_HAL_ADC_INTERRUPT_MULTI_ADC.ewp</path>
  </project>
  <batchBuild />
</workspace>
